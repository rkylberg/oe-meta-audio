SRC_URI = "git://git.kernel.org/pub/scm/utils/dtc/dtc.git"
SRCREV = "5d4a8b9c4c5145bd509bff20780270e00547c80a"
