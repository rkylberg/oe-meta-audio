require jack2.inc

## SRCREV = "ce825c6a6b57bb1235782fa475317b5e0e833cff"
SRCREV = "54ada6e5450c71fea6f2eef98b6661720915efb4"
PV = "1.9.11"
