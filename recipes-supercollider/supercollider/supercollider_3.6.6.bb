require supercollider.inc

SRC_URI = "gitsm://github.com/rkylberg/supercollider;protocol=git;branch=fido"

SRCREV = "5a75e4c6a37a75b64cb454aeb4ea4d8548c697f2"
